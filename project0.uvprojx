# Keil uVision project project0.uvprojx, settings and files
target project0 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project0
  AfterMake: fromelf --bin --output .\rvmdk\project0.bin .\rvmdk\project0.axf
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: ..;.\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: project0.sct
  link misc: --entry Reset_Handler
  group Source
    ./: project0.c startup_rvmdk.S
  group Libraries
    ./driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
  group Bsp
    ./drivers/: buttons.c rgb.c
    ./utils/: uartstdio.c
software components: CMSIS:CORE 5.4.0
